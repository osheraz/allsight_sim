Commit message: multiple object support

File: assets/objects/ellipse_small.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.02; visual mesh filename=textured_sphere_smooth.obj scale=0.02 0.02 0.002
